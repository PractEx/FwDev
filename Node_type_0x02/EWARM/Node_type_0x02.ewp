# IAR project Node_type_0x02.ewp, settings and files
configuration Node_type_0x02 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L011K4 ST STM32L011K4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L011xx; USE_STM32L0XX_NUCLEO_32
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\Drivers\CMSIS\Include; ..\Drivers\BSP
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Node_type_0x02.out
  ILINK.IlinkIcfFile: stm32l011xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l011xx.s
  group Application/User
    ../Src/: dma.c gpio.c main.c stm32l0xx_hal_msp.c stm32l0xx_it.c tim.c usart.c
  group Drivers/BSP/stm32l0xx_nucleo_32
    ../Drivers/BSP/STM32L0xx_Nucleo_32/: stm32l0xx_nucleo_32.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
