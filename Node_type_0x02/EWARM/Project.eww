<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Node_type_0x02.ewp</path>
  </project>
  <batchBuild />
</workspace>
